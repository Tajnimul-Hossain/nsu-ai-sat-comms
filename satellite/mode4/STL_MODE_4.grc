options:
  parameters:
    generate_options: qt_gui
    id: STL_MODE_4
    output_language: python
    title: STL MODE 4
  states: {}

blocks:
- name: audio_rate
  id: variable
  parameters:
    value: '48000'
  states: {}
- name: baud
  id: variable
  parameters:
    value: '1200'
  states: {}
- name: deviation
  id: variable
  parameters:
    value: '3000'
  states: {}
- name: excess_bw
  id: variable
  parameters:
    value: '0.35'
  states: {}
- name: nfilts
  id: variable
  parameters:
    value: '32'
  states: {}
- name: qpsk
  id: variable_constellation_rect
  parameters:
    const_points: '[-1-1j, -1+1j, 1+1j, 1-1j]'
    imag_sect: '2'
    real_sect: '2'
    rot_sym: '4'
    sym_map: '[0, 1, 3, 2]'
    w_imag_sect: '2'
    w_real_sect: '2'
  states: {}
- name: samp_rate
  id: variable
  parameters:
    value: '38400'
  states: {}
- name: samp_rate_0
  id: variable
  parameters:
    value: '2400000'
  states: {}
- name: samp_rate_1
  id: variable
  parameters:
    value: '2000000'
  states: {}
- name: samp_rate_2
  id: variable
  parameters:
    value: '48000'
  states: {}
- name: samp_rate_3
  id: variable
  parameters:
    value: '48000'
  states: {}
- name: sps
  id: variable
  parameters:
    value: '4'
  states: {}
- name: sps_0
  id: variable
  parameters:
    value: '40'
  states: {}
- name: sym_rate
  id: variable
  parameters:
    value: '9600'
  states: {}
- name: analog_const_source_x_0
  id: analog_const_source_x
  parameters:
    const: '0'
    type: float
  states: {}
- name: analog_frequency_modulator_fc_0
  id: analog_frequency_modulator_fc
  parameters:
    sensitivity: 2*numpy.pi*deviation/samp_rate_2
  states: {}
- name: analog_quadrature_demod_cf_0
  id: analog_quadrature_demod_cf
  parameters:
    gain: 48000/(2*numpy.pi*deviation)
  states: {}
- name: analog_random_source_x_0
  id: analog_random_source_x
  parameters:
    max: '256'
    min: '0'
    num_samps: '200000'
    repeat: 'True'
    type: byte
  states: {}
- name: analog_sig_source_x_0
  id: analog_sig_source_x
  parameters:
    amp: '1'
    freq: '800'
    offset: '0'
    phase: '0'
    samp_rate: samp_rate
    type: float
    waveform: analog.GR_COS_WAVE
  states: {}
- name: audio_sink_0
  id: audio_sink
  parameters:
    samp_rate: samp_rate_2
  states: {}
- name: audio_sink_1
  id: audio_sink
  parameters:
    samp_rate: samp_rate_3
  states: {}
- name: blocks_char_to_float_0
  id: blocks_char_to_float
  parameters:
    scale: '1'
  states: {}
- name: blocks_char_to_float_1
  id: blocks_char_to_float
  parameters:
    scale: '1'
  states: {}
- name: blocks_complex_to_mag_0
  id: blocks_complex_to_mag
  parameters: {}
  states: {}
- name: blocks_file_sink_0
  id: blocks_file_sink
  parameters:
    file: E:\Communications\Satellite\STL MODE 4\dup_tx
    type: complex
  states: {}
- name: blocks_file_sink_0_0
  id: blocks_file_sink
  parameters:
    file: E:\Communications\Satellite\STL Mode 4\decoded_tc.bin
    type: byte
    unbuffered: 'True'
  states: {}
- name: blocks_file_sink_1
  id: blocks_file_sink
  parameters:
    file: E:\Communications\Satellite\STL MODE 4\eye_tap
    type: complex
    unbuffered: 'True'
  states: {}
- name: blocks_file_sink_10
  id: blocks_file_sink
  parameters:
    file: E:\Communications\Satellite\STL Mode 4\tm_tx
    type: complex
    unbuffered: 'True'
  states: {}
- name: blocks_file_sink_4
  id: blocks_file_sink
  parameters:
    file: E:\Communications\Satellite\STL MODE 4\decoded_beacon
    type: byte
    unbuffered: 'True'
  states: {}
- name: blocks_file_sink_5
  id: blocks_file_sink
  parameters:
    file: E:\Communications\Satellite\STL Mode 4\decoded_tm
    type: byte
    unbuffered: 'True'
  states: {}
- name: blocks_file_sink_5_0
  id: blocks_file_sink
  parameters:
    file: E:\Communications\Satellite\STL MODE 4\beacon_tx
    type: complex
    unbuffered: 'True'
  states: {}
- name: blocks_file_sink_6
  id: blocks_file_sink
  parameters:
    file: E:\Communications\Satellite\STL Mode 4\tc_symbols
    type: float
    unbuffered: 'True'
  states: {}
- name: blocks_float_to_complex_0
  id: blocks_float_to_complex
  parameters: {}
  states: {}
- name: blocks_multiply_xx_0
  id: blocks_multiply_xx
  parameters:
    type: float
  states: {}
- name: blocks_repack_bits_bb_0
  id: blocks_repack_bits_bb
  parameters:
    endianness: gr.GR_LSB_FIRST
    k: '8'
    l: '1'
  states: {}
- name: blocks_repack_bits_bb_1
  id: blocks_repack_bits_bb
  parameters:
    endianness: gr.GR_LSB_FIRST
    k: '1'
    l: '8'
  states: {}
- name: blocks_repeat_0
  id: blocks_repeat
  parameters:
    interp: '40'
    type: float
  states: {}
- name: blocks_repeat_1
  id: blocks_repeat
  parameters:
    interp: '4800'
    type: byte
  states: {}
- name: blocks_tag_debug_1
  id: blocks_tag_debug
  parameters:
    filter: '"sync"'
    name: tc_sync_debug
    type: byte
  states: {}
- name: blocks_throttle2_0
  id: blocks_throttle2
  parameters:
    samples_per_second: samp_rate_1
    type: complex
  states: {}
- name: blocks_throttle2_0_0
  id: blocks_throttle2
  parameters:
    limit: items
    samples_per_second: samp_rate_2
    type: complex
  states: {}
- name: blocks_throttle2_1
  id: blocks_throttle2
  parameters:
    samples_per_second: samp_rate_3
    type: complex
  states: {}
- name: blocks_throttle2_2
  id: blocks_throttle2
  parameters:
    samples_per_second: samp_rate
    type: complex
  states: {}
- name: blocks_vector_source_x_0
  id: blocks_vector_source_x
  parameters:
    repeat: 'True'
    type: byte
    vector: (71, 170, 83, 16)
  states: {}
- name: blocks_vector_source_x_1
  id: blocks_vector_source_x
  parameters:
    repeat: 'True'
    type: byte
    vector: (71, 170, 83, 16)
  states: {}
- name: blocks_vector_source_x_2
  id: blocks_vector_source_x
  parameters:
    repeat: 'True'
    type: byte
    vector: (1,0,1,0,1,0,0,0,1,1,1,0,1,1,1,0,1,1,1,0,0,0,1,0,1,0,1,0,0,0,0,0,0,0)
  states: {}
- name: channels_channel_model_0
  id: channels_channel_model
  parameters:
    epsilon: '1.0'
    freq_offset: '0.0'
    noise_voltage: '0.01'
    seed: '0'
    taps: '1.0'
  states: {}
- name: channels_channel_model_0_0
  id: channels_channel_model
  parameters:
    epsilon: '1.0'
    freq_offset: '0'
    noise_voltage: '0.05'
    seed: '0'
    taps: '1.0'
  states: {}
- name: channels_channel_model_1
  id: channels_channel_model
  parameters:
    epsilon: '1.0'
    freq_offset: '0.0'
    noise_voltage: '0.05'
    seed: '0'
    taps: '1.0'
  states: {}
- name: digital_binary_slicer_fb_0
  id: digital_binary_slicer_fb
  parameters: {}
  states: {}
- name: digital_binary_slicer_fb_1
  id: digital_binary_slicer_fb
  parameters: {}
  states: {}
- name: digital_chunks_to_symbols_xx_0
  id: digital_chunks_to_symbols_xx
  parameters:
    dimension: '1'
    in_type: byte
    out_type: float
    symbol_table: '[-1.0, 1.0]'
  states: {}
- name: digital_constellation_modulator_0
  id: digital_constellation_modulator
  parameters:
    constellation: qpsk
    differential: 'True'
    excess_bw: excess_bw
    samples_per_symbol: sps
  states: {}
- name: digital_correlate_access_code_tag_xx_0
  id: digital_correlate_access_code_tag_xx
  parameters:
    access_code: '101010'
    tagname: tc_sync
    threshold: '0'
    type: byte
  states: {}
- name: digital_gfsk_demod_0
  id: digital_gfsk_demod
  parameters:
    freq_error: '0.0'
    gain_mu: '0.175'
    mu: '0.5'
    omega_relative_limit: '0.005'
    samples_per_symbol: '5'
    sensitivity: '0.5'
  states: {}
- name: digital_gfsk_mod_0
  id: digital_gfsk_mod
  parameters:
    bt: '0.35'
    samples_per_symbol: '5'
    sensitivity: '0.5'
  states: {}
- name: digital_symbol_sync_xx_0
  id: digital_symbol_sync_xx
  parameters:
    damping: '1.0'
    loop_bw: '0.045'
    max_dev: '1.5'
    nfilters: '128'
    osps: '1'
    resamp_type: digital.IR_PFB_NO_MF
    sps: '40'
    ted_gain: '1.0'
    ted_type: digital.TED_MUELLER_AND_MULLER
    type: ff
  states: {}
- name: low_pass_filter_0
  id: low_pass_filter
  parameters:
    cutoff_freq: '4000'
    decim: '1'
    gain: '1'
    samp_rate: samp_rate_2
    type: fir_filter_fff
    width: '1000'
    win: window.WIN_HAMMING
  states: {}
- name: low_pass_filter_1
  id: low_pass_filter
  parameters:
    comment: beacon_shaping
    cutoff_freq: '100'
    decim: '1'
    gain: '1'
    samp_rate: samp_rate
    type: fir_filter_fff
    width: '50'
    win: window.WIN_HAMMING
  states: {}
- name: qtgui_const_sink_x_0_0
  id: qtgui_const_sink_x
  parameters:
    grid: 'True'
    gui_hint: 5,0,1,1
    name: '"Data Raw Constellation"'
    size: '2048'
    type: complex
  states: {}
- name: qtgui_freq_sink_x_0
  id: qtgui_freq_sink_x
  parameters:
    bw: samp_rate_2
    ctrlpanel: 'True'
    fc: '437325000'
    fftsize: '1024'
    grid: 'True'
    gui_hint: 2,0,1,1
    name: '"Telemetry Transmitter (VHF 437.325 MHz)"'
    type: complex
  states: {}
- name: qtgui_freq_sink_x_0_0
  id: qtgui_freq_sink_x
  parameters:
    bw: samp_rate_1
    color1: '"magenta"'
    ctrlpanel: 'True'
    fc: '2245000000'
    fftsize: '2048'
    grid: 'True'
    gui_hint: 4,0,1,1
    name: '"Data Transmitter (S-band 2245 MHz)"'
    type: complex
  states: {}
- name: qtgui_freq_sink_x_0_1
  id: qtgui_freq_sink_x
  parameters:
    bw: samp_rate_2
    ctrlpanel: 'True'
    fc: '437100000'
    fftsize: '2048'
    grid: 'True'
    gui_hint: 0,0,1,1
    name: '"Telecommand Receiver (437.1 MHz)"'
    type: complex
  states: {}
- name: qtgui_freq_sink_x_1_1
  id: qtgui_freq_sink_x
  parameters:
    average: '0.2'
    bw: samp_rate_2
    ctrlpanel: 'True'
    fc: '145840000'
    fftsize: '2048'
    grid: 'True'
    gui_hint: 6,0,1,1
    name: '"Beacon Transmitter (145.84 MHz)"'
    norm_window: 'True'
    showports: 'True'
    type: complex
  states: {}
- name: qtgui_time_sink_x_0
  id: qtgui_time_sink_x
  parameters:
    ctrlpanel: 'True'
    grid: 'True'
    gui_hint: 7,0,1,1
    name: '"Beacon Envelope"'
    size: '24000'
    srate: samp_rate
    type: float
  states: {}
- name: qtgui_time_sink_x_0_0
  id: qtgui_time_sink_x
  parameters:
    autoscale: 'True'
    ctrlpanel: 'True'
    grid: 'True'
    gui_hint: 1,0,1,1
    name: '"Telecommand Recovered Tone"'
    size: '1024'
    srate: samp_rate_2
    type: float
  states: {}
- name: qtgui_time_sink_x_0_0_0
  id: qtgui_time_sink_x
  parameters:
    autoscale: 'True'
    grid: 'True'
    gui_hint: 3,0,1,1
    name: '"Telemetry TX Waveform"'
    size: '960'
    srate: samp_rate_2
    type: complex
    ymax: '1.2'
    ymin: '-1.2'
    yunit: '"a.u."'
  states: {}

connections:
- [analog_const_source_x_0, '0', blocks_float_to_complex_0, '1']
- [analog_frequency_modulator_fc_0, '0', blocks_throttle2_0_0, '0']
- [analog_quadrature_demod_cf_0, '0', audio_sink_0, '0']
- [analog_quadrature_demod_cf_0, '0', low_pass_filter_0, '0']
- [analog_quadrature_demod_cf_0, '0', qtgui_time_sink_x_0_0, '0']
- [analog_random_source_x_0, '0', digital_constellation_modulator_0, '0']
- [analog_sig_source_x_0, '0', blocks_multiply_xx_0, '1']
- [blocks_char_to_float_0, '0', audio_sink_1, '0']
- [blocks_char_to_float_1, '0', low_pass_filter_1, '0']
- [blocks_complex_to_mag_0, '0', digital_binary_slicer_fb_1, '0']
- [blocks_float_to_complex_0, '0', blocks_file_sink_5_0, '0']
- [blocks_float_to_complex_0, '0', blocks_throttle2_2, '0']
- [blocks_multiply_xx_0, '0', blocks_float_to_complex_0, '0']
- [blocks_multiply_xx_0, '0', qtgui_time_sink_x_0, '0']
- [blocks_repack_bits_bb_0, '0', digital_chunks_to_symbols_xx_0, '0']
- [blocks_repack_bits_bb_1, '0', blocks_file_sink_0_0, '0']
- [blocks_repeat_0, '0', analog_frequency_modulator_fc_0, '0']
- [blocks_repeat_1, '0', blocks_char_to_float_1, '0']
- [blocks_throttle2_0, '0', blocks_file_sink_0, '0']
- [blocks_throttle2_0, '0', qtgui_const_sink_x_0_0, '0']
- [blocks_throttle2_0, '0', qtgui_freq_sink_x_0_0, '0']
- [blocks_throttle2_0_0, '0', blocks_file_sink_1, '0']
- [blocks_throttle2_0_0, '0', channels_channel_model_0_0, '0']
- [blocks_throttle2_1, '0', blocks_file_sink_10, '0']
- [blocks_throttle2_1, '0', channels_channel_model_0, '0']
- [blocks_throttle2_1, '0', qtgui_freq_sink_x_0, '0']
- [blocks_throttle2_1, '0', qtgui_time_sink_x_0_0_0, '0']
- [blocks_throttle2_2, '0', channels_channel_model_1, '0']
- [blocks_vector_source_x_0, '0', blocks_repack_bits_bb_0, '0']
- [blocks_vector_source_x_1, '0', digital_gfsk_mod_0, '0']
- [blocks_vector_source_x_2, '0', blocks_repeat_1, '0']
- [channels_channel_model_0, '0', digital_gfsk_demod_0, '0']
- [channels_channel_model_0_0, '0', analog_quadrature_demod_cf_0, '0']
- [channels_channel_model_0_0, '0', qtgui_freq_sink_x_0_1, '0']
- [channels_channel_model_1, '0', blocks_complex_to_mag_0, '0']
- [channels_channel_model_1, '0', qtgui_freq_sink_x_1_1, '0']
- [digital_binary_slicer_fb_0, '0', digital_correlate_access_code_tag_xx_0, '0']
- [digital_binary_slicer_fb_1, '0', blocks_file_sink_4, '0']
- [digital_chunks_to_symbols_xx_0, '0', blocks_repeat_0, '0']
- [digital_constellation_modulator_0, '0', blocks_throttle2_0, '0']
- [digital_correlate_access_code_tag_xx_0, '0', blocks_repack_bits_bb_1, '0']
- [digital_correlate_access_code_tag_xx_0, '0', blocks_tag_debug_1, '0']
- [digital_gfsk_demod_0, '0', blocks_char_to_float_0, '0']
- [digital_gfsk_demod_0, '0', blocks_file_sink_5, '0']
- [digital_gfsk_mod_0, '0', blocks_throttle2_1, '0']
- [digital_symbol_sync_xx_0, '0', blocks_file_sink_6, '0']
- [digital_symbol_sync_xx_0, '0', digital_binary_slicer_fb_0, '0']
- [low_pass_filter_0, '0', digital_symbol_sync_xx_0, '0']
- [low_pass_filter_1, '0', blocks_multiply_xx_0, '0']

metadata:
  file_format: 1
  grc_version: 3.10.12.0
