options:
  parameters:
    generate_options: qt_gui
    id: GND_MODE_2
    output_language: python
    title: Ground Station Mode 2
  states: {}

blocks:
- name: Sensitivity
  id: variable
  parameters:
    value: 2*numpy.pi*3000/samp_rate
  states: {}
- name: constellation
  id: variable_constellation_rect
  parameters:
    const_points: '[-1-1j, -1+1j, 1+1j, 1-1j]'
    imag_sect: '2'
    real_sect: '2'
    rot_sym: '4'
    sym_map: '[0, 1, 3, 2]'
    w_imag_sect: '2'
    w_real_sect: '2'
  states: {}
- name: samp_rate
  id: variable
  parameters:
    value: '48000'
  states: {}
- name: analog_const_source_x_0
  id: analog_const_source_x
  parameters:
    const: '0'
    type: float
  states: {}
- name: analog_frequency_modulator_fc_0
  id: analog_frequency_modulator_fc
  parameters:
    sensitivity: Sensitivity
  states: {}
- name: analog_quadrature_demod_cf_0
  id: analog_quadrature_demod_cf
  parameters:
    gain: 1/Sensitivity
  states: {}
- name: analog_quadrature_demod_cf_0_0
  id: analog_quadrature_demod_cf
  parameters:
    gain: '2'
  states: {}
- name: analog_random_source_x_0
  id: analog_random_source_x
  parameters:
    max: '2'
    min: '0'
    num_samps: '1000'
    repeat: 'True'
    type: byte
  states: {}
- name: analog_random_source_x_0_0
  id: analog_random_source_x
  parameters:
    max: '256'
    min: '0'
    num_samps: '1000'
    repeat: 'True'
    type: byte
  states: {}
- name: analog_random_source_x_1
  id: analog_random_source_x
  parameters:
    max: '256'
    min: '0'
    num_samps: '10000'
    repeat: 'True'
    type: byte
  states: {}
- name: analog_random_source_x_1_0
  id: analog_random_source_x
  parameters:
    max: '256'
    min: '0'
    num_samps: '10000'
    repeat: 'True'
    type: byte
  states: {}
- name: analog_sig_source_x_0
  id: analog_sig_source_x
  parameters:
    amp: '1'
    freq: '8.333'
    offset: '0'
    phase: '0'
    samp_rate: samp_rate
    type: float
    waveform: analog.GR_SQR_WAVE
  states: {}
- name: audio_sink_0
  id: audio_sink
  parameters:
    samp_rate: samp_rate
  states: {}
- name: audio_sink_0_0
  id: audio_sink
  parameters:
    samp_rate: samp_rate
  states: {}
- name: audio_sink_0_0_0
  id: audio_sink
  parameters:
    samp_rate: samp_rate
  states: {}
- name: blocks_complex_to_mag_0
  id: blocks_complex_to_mag
  parameters: {}
  states: {}
- name: blocks_file_sink_0
  id: blocks_file_sink
  parameters:
    file: E:\Communications\Satellite\GND MODE 2\telecommand_tx_mode2
    type: complex
    unbuffered: 'True'
  states: {}
- name: blocks_file_sink_0_0
  id: blocks_file_sink
  parameters:
    file: E:\Communications\Satellite\GND MODE 2\telemetry_rx_mode2
    type: byte
    unbuffered: 'True'
  states: {}
- name: blocks_file_sink_0_0_0
  id: blocks_file_sink
  parameters:
    file: E:\Communications\Satellite\GND MODE 2\dc_tx_mode2
    type: complex
    unbuffered: 'True'
  states: {}
- name: blocks_file_sink_0_0_0_0
  id: blocks_file_sink
  parameters:
    file: E:\Communications\Satellite\GND MODE 2\dc_rx_mode2
    type: byte
    unbuffered: 'True'
  states: {}
- name: blocks_file_sink_0_1
  id: blocks_file_sink
  parameters:
    file: E:\Communications\Satellite\GND MODE 2\beacon_rx_mode2
    type: float
    unbuffered: 'True'
  states: {}
- name: blocks_file_sink_1
  id: blocks_file_sink
  parameters:
    file: E:\Communications\Satellite\GND MODE 2\eye_tap_mode2
    type: complex
    unbuffered: 'True'
  states: {}
- name: blocks_float_to_complex_0
  id: blocks_float_to_complex
  parameters: {}
  states: {}
- name: blocks_multiply_xx_0
  id: blocks_multiply_xx
  parameters:
    type: float
  states: {}
- name: blocks_repeat_0
  id: blocks_repeat
  parameters:
    interp: '40'
    type: float
  states: {}
- name: blocks_threshold_ff_0
  id: blocks_threshold_ff
  parameters:
    high: '0.7'
    init: '0'
    low: '0.3'
  states: {}
- name: blocks_throttle2_0
  id: blocks_throttle2
  parameters:
    samples_per_second: '48000'
    type: complex
  states: {}
- name: blocks_throttle2_0_0
  id: blocks_throttle2
  parameters:
    samples_per_second: '48000'
    type: complex
  states: {}
- name: blocks_throttle2_1
  id: blocks_throttle2
  parameters:
    samples_per_second: samp_rate
    type: complex
  states: {}
- name: blocks_throttle2_2
  id: blocks_throttle2
  parameters:
    samples_per_second: samp_rate
    type: complex
  states: {}
- name: blocks_throttle2_2_0
  id: blocks_throttle2
  parameters:
    samples_per_second: samp_rate
    type: complex
  states: {}
- name: digital_chunks_to_symbols_xx_0
  id: digital_chunks_to_symbols_xx
  parameters:
    dimension: '1'
    in_type: byte
    out_type: float
    symbol_table: (-1, 1)
  states: {}
- name: digital_constellation_decoder_cb_0
  id: digital_constellation_decoder_cb
  parameters:
    constellation: constellation
  states: {}
- name: digital_constellation_modulator_0
  id: digital_constellation_modulator
  parameters:
    constellation: constellation
    differential: 'True'
    excess_bw: '0.35'
    samples_per_symbol: '5'
  states: {}
- name: digital_constellation_modulator_0_0
  id: digital_constellation_modulator
  parameters:
    constellation: constellation
    differential: 'False'
    excess_bw: '0.35'
    samples_per_symbol: '5'
  states: {}
- name: digital_costas_loop_cc_0
  id: digital_costas_loop_cc
  parameters:
    order: '4'
    w: '0.02'
  states: {}
- name: digital_diff_decoder_bb_0
  id: digital_diff_decoder_bb
  parameters:
    coding: digital.DIFF_DIFFERENTIAL
    modulus: '4'
  states: {}
- name: digital_gfsk_demod_0
  id: digital_gfsk_demod
  parameters:
    freq_error: '0.0'
    gain_mu: '0.175'
    mu: '0.5'
    omega_relative_limit: '0.005'
    samples_per_symbol: '5'
    sensitivity: '0.5'
  states: {}
- name: digital_gfsk_mod_0
  id: digital_gfsk_mod
  parameters:
    bt: '0.35'
    samples_per_symbol: '5'
    sensitivity: '0.5'
  states: {}
- name: digital_map_bb_0
  id: digital_map_bb
  parameters:
    map: '[0,1,3,2]'
  states: {}
- name: digital_symbol_sync_xx_0
  id: digital_symbol_sync_xx
  parameters:
    damping: '1.0'
    loop_bw: '0.045'
    max_dev: '1.5'
    osps: '1'
    resamp_type: digital.IR_MMSE_8TAP
    sps: '5'
    ted_gain: '1.0'
    ted_type: digital.TED_MUELLER_AND_MULLER
    type: cc
  states: {}
- name: qtgui_const_sink_x_0
  id: qtgui_const_sink_x
  parameters:
    grid: 'True'
    gui_hint: 6,0,1,1
    name: '"Data Recovered Constellation"'
    size: '2048'
    type: complex
  states: {}
- name: qtgui_freq_sink_x_0
  id: qtgui_freq_sink_x
  parameters:
    bw: samp_rate
    fc: '437100000'
    fftsize: '2048'
    grid: 'True'
    gui_hint: 0,0,1,1
    label: Magnitude
    name: '"Telecommand Transmitter (437.1 MHz)"'
    norm_window: 'True'
    type: complex
  states: {}
- name: qtgui_freq_sink_x_0_0
  id: qtgui_freq_sink_x
  parameters:
    bw: samp_rate
    color1: '"green"'
    fc: '437325000'
    fftsize: '2048'
    grid: 'True'
    gui_hint: 2,0,1,1
    label: Magnitude
    label1: GFSK Telemetry
    name: '"Telemetry Receiver (437.325 MHz)"'
    norm_window: 'True'
    type: complex
  states: {}
- name: qtgui_freq_sink_x_0_0_0
  id: qtgui_freq_sink_x
  parameters:
    autoscale: 'True'
    bw: samp_rate
    color1: '"green"'
    ctrlpanel: 'True'
    fc: '145840000'
    fftsize: '2048'
    grid: 'True'
    gui_hint: 7,0,1,1
    label: Magnitude
    label1: Beacon
    name: '"Beacon Receiver (145.84 MHz)"'
    norm_window: 'True'
    type: complex
  states: {}
- name: qtgui_freq_sink_x_0_0_1
  id: qtgui_freq_sink_x
  parameters:
    bw: samp_rate
    color1: '"green"'
    fc: '436500000'
    fftsize: '2048'
    grid: 'True'
    gui_hint: 4,0,1,1
    label: Magnitude
    label1: GFSK Telemetry
    name: '"Data Transmitter (UHF 436.5 MHz)"'
    norm_window: 'True'
    type: complex
  states: {}
- name: qtgui_freq_sink_x_0_0_1_0
  id: qtgui_freq_sink_x
  parameters:
    bw: samp_rate
    color1: '"green"'
    fc: '435800000'
    fftsize: '2048'
    grid: 'True'
    gui_hint: 5,0,1,1
    label: Magnitude
    label1: QPSK Data Telemetry
    name: '"Data Receiver (UHF 435.8 MHz)"'
    norm_window: 'True'
    type: complex
  states: {}
- name: qtgui_time_sink_x_0
  id: qtgui_time_sink_x
  parameters:
    autoscale: 'True'
    grid: 'True'
    gui_hint: 1,0,1,1
    name: '"Telecommand TX Waveform"'
    size: '960'
    srate: samp_rate
    type: complex
    ymax: '1.2'
    ymin: '-1.2'
    yunit: '"a.u."'
  states: {}
- name: qtgui_time_sink_x_0_0
  id: qtgui_time_sink_x
  parameters:
    grid: 'True'
    gui_hint: 3,0,1,1
    name: '"Telemetry Recovered Waveform"'
    size: '960'
    srate: samp_rate
    type: complex
    ymax: '1.2'
    ymin: '-1.2'
    yunit: '"a.u."'
  states: {}
- name: qtgui_time_sink_x_0_0_0
  id: qtgui_time_sink_x
  parameters:
    grid: 'True'
    gui_hint: 8,0,1,1
    name: '"Beacon Envelope"'
    size: '24000'
    srate: samp_rate
    type: complex
    ymax: '1.2'
    ymin: '-0.2'
    yunit: '"a.u."'
  states: {}

connections:
- [analog_const_source_x_0, '0', blocks_float_to_complex_0, '1']
- [analog_frequency_modulator_fc_0, '0', blocks_throttle2_0, '0']
- [analog_quadrature_demod_cf_0, '0', audio_sink_0_0, '0']
- [analog_quadrature_demod_cf_0_0, '0', audio_sink_0_0_0, '0']
- [analog_random_source_x_0, '0', digital_chunks_to_symbols_xx_0, '0']
- [analog_random_source_x_0_0, '0', digital_gfsk_mod_0, '0']
- [analog_random_source_x_1, '0', digital_constellation_modulator_0, '0']
- [analog_random_source_x_1_0, '0', digital_constellation_modulator_0_0, '0']
- [analog_sig_source_x_0, '0', blocks_float_to_complex_0, '0']
- [analog_sig_source_x_0, '0', blocks_multiply_xx_0, '1']
- [blocks_complex_to_mag_0, '0', blocks_threshold_ff_0, '0']
- [blocks_float_to_complex_0, '0', blocks_throttle2_0_0, '0']
- [blocks_multiply_xx_0, '0', audio_sink_0, '0']
- [blocks_repeat_0, '0', analog_frequency_modulator_fc_0, '0']
- [blocks_threshold_ff_0, '0', blocks_file_sink_0_1, '0']
- [blocks_threshold_ff_0, '0', blocks_multiply_xx_0, '0']
- [blocks_throttle2_0, '0', analog_quadrature_demod_cf_0, '0']
- [blocks_throttle2_0, '0', blocks_file_sink_0, '0']
- [blocks_throttle2_0, '0', qtgui_freq_sink_x_0, '0']
- [blocks_throttle2_0, '0', qtgui_time_sink_x_0, '0']
- [blocks_throttle2_0_0, '0', blocks_complex_to_mag_0, '0']
- [blocks_throttle2_0_0, '0', qtgui_freq_sink_x_0_0_0, '0']
- [blocks_throttle2_0_0, '0', qtgui_time_sink_x_0_0_0, '0']
- [blocks_throttle2_1, '0', analog_quadrature_demod_cf_0_0, '0']
- [blocks_throttle2_1, '0', digital_gfsk_demod_0, '0']
- [blocks_throttle2_1, '0', qtgui_freq_sink_x_0_0, '0']
- [blocks_throttle2_1, '0', qtgui_time_sink_x_0_0, '0']
- [blocks_throttle2_2, '0', blocks_file_sink_0_0_0, '0']
- [blocks_throttle2_2, '0', qtgui_freq_sink_x_0_0_1, '0']
- [blocks_throttle2_2_0, '0', digital_costas_loop_cc_0, '0']
- [blocks_throttle2_2_0, '0', qtgui_freq_sink_x_0_0_1_0, '0']
- [digital_chunks_to_symbols_xx_0, '0', blocks_repeat_0, '0']
- [digital_constellation_decoder_cb_0, '0', digital_diff_decoder_bb_0, '0']
- [digital_constellation_modulator_0, '0', blocks_throttle2_2, '0']
- [digital_constellation_modulator_0_0, '0', blocks_throttle2_2_0, '0']
- [digital_costas_loop_cc_0, '0', blocks_file_sink_1, '0']
- [digital_costas_loop_cc_0, '0', digital_symbol_sync_xx_0, '0']
- [digital_diff_decoder_bb_0, '0', digital_map_bb_0, '0']
- [digital_gfsk_demod_0, '0', blocks_file_sink_0_0, '0']
- [digital_gfsk_mod_0, '0', blocks_throttle2_1, '0']
- [digital_map_bb_0, '0', blocks_file_sink_0_0_0_0, '0']
- [digital_symbol_sync_xx_0, '0', digital_constellation_decoder_cb_0, '0']
- [digital_symbol_sync_xx_0, '0', qtgui_const_sink_x_0, '0']

metadata:
  file_format: 1
  grc_version: 3.10.12.0
